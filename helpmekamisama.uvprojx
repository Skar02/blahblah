# Keil uVision project helpmekamisama.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: RTOSkami
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=3 wLevel=3
  c include: .\ProjectSkeletonCode\include;.\ioLibrary_Driver-master\ioLibrary_Driver-master\Ethernet;.\ioLibrary_Driver-master\ioLibrary_Driver-master\Ethernet\W5500
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Source Group 1
    ./ProjectSkeletonCode/source/: application.c controller.c peripherals.c app-rtos.c app-client.c app-server.c shared_protocol.h
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L476RGTx/STCubeGenerated/Src/: main.c stm32l4xx_it.c
    ./RTE/Device/STM32L476RGTx/STCubeGenerated/Inc/: stm32l4xx_it.h
  group ioLibrary
    ./ioLibrary_Driver-master/ioLibrary_Driver-master/Ethernet/: socket.c wizchip_conf.c
    ./ioLibrary_Driver-master/ioLibrary_Driver-master/Ethernet/W5500/: w5500.c
target RTOS (6220000::V6.22::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: as above
  output: RTOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=3 wLevel=3
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target Client (6220000::V6.22::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: as above
  output: Client
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=3 wLevel=3
  c define: _ETHERNET_ENABLED _CLIENT_CONFIG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target Server (6220000::V6.22::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: as above
  output: Server
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=3 wLevel=3
  c define: _ETHERNET_ENABLED _SERVER_CONFIG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
software components: CMSIS-View:Event Recorder 1.6.0, CMSIS:CORE 6.1.0, CMSIS:CORE 6.2.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, Compiler:I/O:STDOUT 1.2.0, Device:STM32Cube Framework:STM32CubeMX 1.1.0, Device:STM32Cube HAL:Common 1.13.4, Device:STM32Cube HAL:Cortex 1.13.4, Device:STM32Cube HAL:DMA 1.13.4, Device:STM32Cube HAL:GPIO 1.13.4, Device:STM32Cube HAL:PWR 1.13.4, Device:STM32Cube HAL:RCC 1.13.4, Device:STM32Cube HAL:SPI 1.13.4, Device:STM32Cube HAL:TIM 1.13.4, Device:Startup 1.3.2
